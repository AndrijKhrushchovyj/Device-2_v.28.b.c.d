<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.28\device_2_v_28_1_0_0.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.28\device_2_v_28_11_0_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
